options:
  parameters:
    generate_options: qt_gui
    id: untitled1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: tune
  id: variable_qtgui_range
  parameters:
    start: '95.8'
    step: '0.2'
    stop: '120.1'
    value: '100'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: samp_rate/5
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: tune*1000000
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '5'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '100'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/5
    fc: '100'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/5
    fc: '100'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
